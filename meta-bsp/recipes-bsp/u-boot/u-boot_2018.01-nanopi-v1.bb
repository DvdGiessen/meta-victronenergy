require u-boot.inc
require u-boot-common_${PV}.inc

DEPENDS += "bc-native coreutils-native dtc-native swig-native"
